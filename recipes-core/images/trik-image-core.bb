require trik-image-base.inc
#MKLIBS_OPTIMIZED_IMAGES += "${PN}"
IMAGE_INSTALL += "e2fsprogs"
